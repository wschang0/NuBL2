# Keil uVision project NuBL2.uvprojx, settings and files
target NuBL2 (6120000::V6.12::.\ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.6
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: NuBL2 +hex
  BeforeMake: sign.bat
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L"
  AfterMake: FwSign ./NuBL2/NuBL2.bin ./NuBL2/FwInfo.bin 0x7000
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\NuBL2;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Nuvoton\M2351\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\ThirdParty\FatFs\src
  asm define: Stack_Size=0x2000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\NuBL2.sct
  link misc: --map --first='NuBL2_startup.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
--keep=FwInfo.o(*)
--keep=VerifyNuBL3x.o(*)
  group CMSIS
    ./: NuBL2_startup.s
    ../../../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
  group User
    ../: main.c VerifyNuBL3x.c diskio.c sd.c SDGlue.c
    ../KeyInfo/: NuBL3xKeyStorage.s
    ../FwInfo/: NuBL3xFwInfo.s FwInfo.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c fmc.c MKROMLib_Keil.lib spi.c sdh.c
    ../../../../../ThirdParty/FatFs/src/: ff.c
target NuBL2_Only (6120000::V6.12::.\ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.6
  cpu: as above
  output: NuBL2 +hex
  BeforeMake: sign.bat
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L"
  AfterMake: FwSign .\NuBL2\NuBL2.bin .\NuBL2\FwInfo.bin 0x7000
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\;..\..\NuBL2;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Nuvoton\M2351\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\ThirdParty\FatFs\src
  asm define: Stack_Size=0x2000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\NuBL2.sct
  link misc: --map --first='NuBL2_startup.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
