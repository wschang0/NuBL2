# Keil uVision project NonSecure.uvprojx, settings and files
target tfm_ns (6120000::V6.12::.\ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.6
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: tfm_ns +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=5
  c include: ..\..\;..\..\Nonsecure;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Nuvoton\M2351\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\ThirdParty\FatFs\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: nonsecure.sct
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
    ../../../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
  group User
    ../: main_ns.c diskio.c sd.c SDGlue.c
    ../../: partition_M2351.h
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c gpio.c spi.c sdh.c uart.c
    ../../../../../../trusted-firmware-m/build/secure_fw/: s_veneers.o
    ../../../../../ThirdParty/FatFs/src/: ff.c
